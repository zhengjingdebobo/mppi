# Keil uVision project work_Zxj.uvprojx, settings and files
target work_Zxj (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: work_Zxj +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../CUBOT/Cubot_algorithm;../CUBOT/Cubot_devices;../CUBOT/Cubot_driver;../CUBOT/Cubot_modules;../CUBOT/Cubot_UI;../CUBOT/Cubot_User_Config;../CUBOT/Cubot_vision;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../CUBOT/Cubot_devices_IMU;../CUBOT/Cubot_devices_daemon;../CUBOT/Cubot_devices_Motor;../CUBOT/Cubot_Velocity;../CUBOT/Cubot_Calibration;../CUBOT\Cubot_devices;..\Cubot\Algorithm;..\MDK-ARM;..\CUBOT\Cubot_algorithm
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c adc.c can.c crc.c dac.c dma.c rng.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Cubot/Driver
    ../CUBOT/Cubot_driver/: drv_can.c drv_iic.c drv_spi.c drv_timer.c drv_usart.c drv_dwt.c drv_log.c drv_init.c
  group Cubot/Devices
    ../CUBOT/Cubot_devices/: dr16.c keyboard_mouse_ctrl.c offline_check.c flysky_sbus.c nx16.c hwt101ct.c hwt9053_can.c odom_xdrive.c
  group Cubot/Device/IMU
    ../CUBOT/Cubot_devices_IMU/: BMI088driver.c BMI088Middleware.c controller.c ins_task.c master_process.c QuaternionEKF.c user_lib.c kalman_filter.c seasky_protocol.c crc8.c crc16.c
  group Cubot/Device/Motor
    ../CUBOT/Cubot_devices_Motor/: motor_task.c vesc_motor.c
  group Cubot/Device/Daemon
    ../CUBOT/Cubot_devices_daemon/: daemon.c
  group Cubot/Modules
    ../CUBOT/Cubot_modules/: chassis.c holder.c shoot.c
  group Cubot/Velocity
    ../CUBOT/Cubot_Velocity/: chassis_control.c chassis_control.h chassis_velocity.c chassis_velocity.h chassis_velocity_config.h chassis_velocity_test.h chassis_feedback.c chassis_feedback.h mecanum_kinematics.c mecanum_kinematics.h wheel_feedback.c wheel_feedback.h rpm_compensation.c rpm_compensation.h imu_state.c imu_state.h state_estimator.c state_estimator.h slip_detector.c slip_detector.h chassis_velocity_test.c
  group Cubot/Calibration
    ../CUBOT/Cubot_Calibration/: chassis_rpm_calibration.c chassis_rpm_calibration.h
  group Cubot/Algorithm
    ../CUBOT/Cubot_algorithm/: Get_angle.c kalman.c pid.c
    ./: path_tracker.c path_tracker.h
  group User/Config
    ../CUBOT/Cubot_User_Config/: control_logic.c hardware_config.c chassis_debug.h
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4l_math.lib
software components: CMSIS:CORE 6.2.0
